# Keil uVision project Scorobot_Kinect.uvproj, settings and files
target Scorobot (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Scorobot_Kinect
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER STM32F4XX,USE_USB_OTG_FS,__CC_ARM
  c include: .\scr;..\Device\STM32F4xx\Include;..\CMSIS\Include;..\STM32F4xx_StdPeriph_Driver\inc;..\STM32_USB_Device_Library\Class\hid_custom\inc;..\STM32_USB_Device_Library\Core\inc;..\STM32_USB_OTG_Driver\inc;.\pid;.\USB_HID;.\str
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: startup_stm32f40xx.s
    ./scr/: main.c stm32f4_discovery.c stm32f4xx_it.c usb_bsp.c usbd_desc.c usbd_usr.c
    ./USB_HID/: USB_HID.c
    ./pid/: systick.c
    ./str/: Inverse_Kinematic.c SCOROBOT_INVERSE.c caculator_setpoint.c Debug_Timer.c
  group Lib
    ./scr/: system_stm32f4xx.c
    ../STM32_USB_Device_Library/Class/hid_custom/src/: usbd_hid_core.c
    ../STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
    ../Device/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_adc.c
  group PID
    ./pid/: Motor.c Pid.c Sample_PID.c Sensor.c Structure.c
